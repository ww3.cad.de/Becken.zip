# Autodesk Inventor part: Becken
## iProperties
Created: 2005-05
Part Number: Becken
Document SubType Name: Modeling
Designer: Heiko
Author: Heiko
